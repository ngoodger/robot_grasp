Commit message: Added limit for planar gripper.

File: niryo_one_description/urdf/niryo_one.urdf (robot description, URDF)
Before this commit: robot niryo_one, 10 links, 9 joints
Joints:
- joint hand_gripper_finger_joint: limit (none) -> lower=-1.0 upper=1.0 effort=1 velocity=1.0
